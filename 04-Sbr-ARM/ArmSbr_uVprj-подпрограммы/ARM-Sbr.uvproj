# Keil uVision project ARM-Sbr.uvproj, settings and files
target ARM-Sbr-no-Op (ARM-GNU)
  device: ADuC7026 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: ARM-Sbr
  group SourceFiles
    ./Src/: startup.s ARM-Sbr.c
target ARM-Sbr-Lev1 (ARM-GNU)
  device: ADuC7026 Analog Devices
  cpu: as above
  output: ARM-Sbr
