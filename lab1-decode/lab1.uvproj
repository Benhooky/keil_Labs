# Keil uVision project lab1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lab1
  c flags: Optim=1
  c include: .\STM32_CMSIS\CoreSupport;.\STM32_CMSIS\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: src.c
  group StartUp
    ./: startup_stm32f10x_md_vl.s
  group CMSIS
    ./STM32_CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
